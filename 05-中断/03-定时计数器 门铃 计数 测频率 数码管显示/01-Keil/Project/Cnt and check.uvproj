# Keil uVision project Cnt and check.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Cnt and check +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ../Source/: display.c main.c
